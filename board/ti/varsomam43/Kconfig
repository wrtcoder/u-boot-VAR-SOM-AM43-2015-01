## board/ti/varsomam43/Kconfig
```kconfig
config SYS_BOARD
	default "varsomam43"

config SYS_VENDOR
	default "ti"

config SYS_SOC
	default "am33xx"

config SYS_CONFIG_NAME
	default "varsomam43"
```
